# Keil uVision project Multitasking_8051.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Multitasking_8051 +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: MAKE_WITH_FREE_LIB, SYSI
  c include: C:\salvo\inc
  group Src
    ./: STARTUP.A51 main.c salvocfg.h
  group lib
    C:/salvo/lib/kc51/: sfc51sdmb.lib
  group Salvo src
    C:/salvo/src/: mem.c
